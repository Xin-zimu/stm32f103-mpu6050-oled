# Keil uVision project led.uvprojx, settings and files
target led (5060960::V5.06 update 7 (build 960)::.)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\SYSTEM\usart;..\SYSTEM\timing;..\SYSTEM\tim;..\SYSTEM\sys;..\SYSTEM\delay;..\Libraries\CMSIS;..\Libraries\inc;..\Libraries\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h led.c led.h app_light_control.c app_light_control.h oled.h oled.c light_sensor.c light_sensor.h ds18b20.c ds18b20.h app_light.c app_light.h app_temp.c app_temp.h joystick.c joystick.h app_ui.c app_ui.h app_uart_practice.c app_uart_practice.h mpu6050.c mpu6050.h
  group SYS
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/timing/: timing.c timing.h
